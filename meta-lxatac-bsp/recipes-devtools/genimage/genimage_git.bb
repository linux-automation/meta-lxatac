require recipes-devtools/genimage/genimage.inc

SRCREV = "47c23c49af9d8dedd9cbed8ef851ec36b6629287"
SRC_URI = "git://git@github.com/pengutronix/genimage.git;protocol=https;branch=master"
S = "${WORKDIR}/git"
