FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-local-Fix-detection-of-scan-element-channels.patch"

