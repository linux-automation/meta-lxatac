# Release commit created 2026-11-17 22:43:49 +0100
PV = "2026.11.0"
SRC_URI[sha256sum] = "81e10862fd4178aa10d8704e98f023c47ed7d1597f15e31d04e369599e1bd160"

BAREBOX_TOOLS:append = " rk-usb-loader"
