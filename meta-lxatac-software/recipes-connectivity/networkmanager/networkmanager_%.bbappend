# The terminal user interface is the one we document in the manual.
# Make sure it is installed.
PACKAGECONFIG:append = "nmtui"
