# Update the version from 4.6.4 in meta-oe to 4.6.6 to fix a number of
# CVEs
PV = "4.6.6"

SRC_URI[sha256sum] = "27e7ff780cd68a7466082be82ca26c06a002e74a71646ef3a6e4683e444c1a86"
