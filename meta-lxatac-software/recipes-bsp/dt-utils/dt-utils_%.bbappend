FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-libdt-prefer-first-found-disk-when-looking-for-block.patch"

