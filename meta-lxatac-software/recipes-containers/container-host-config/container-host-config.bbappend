# Install our own storage.conf
FILESEXTRAPATHS:prepend := "${THISDIR}/files:" 
