do_install:append() {
   rm ${D}${bindir}/usbsdmux-service
}
