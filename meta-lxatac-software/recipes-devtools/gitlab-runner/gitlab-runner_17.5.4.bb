require gitlab-runner.inc

SRC_URI = "git://gitlab.com/gitlab-org/gitlab-runner.git;branch=17-5-stable;protocol=https"
SRCREV = "d8d88d9e25349cfb7eefdc9a55f49eab794bb27a"
