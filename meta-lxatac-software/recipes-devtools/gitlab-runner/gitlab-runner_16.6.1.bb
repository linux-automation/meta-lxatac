require gitlab-runner.inc

SRC_URI = "git://gitlab.com/gitlab-org/gitlab-runner.git;branch=16-6-stable;protocol=https"
SRCREV = "f5da3c5adf55e55004e0dae2a2e1476f8407c087"
