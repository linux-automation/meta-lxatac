require gitlab-runner.inc

SRCBRANCH = "18-5-stable"
SRCREV = "bda84871762de5fb1573f4495940e044e8a5a010"
