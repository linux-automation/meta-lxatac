require gitlab-runner.inc

SRCBRANCH = "18-3-stable"
SRCREV = "5a021a1c14edadc683ee4b1f0a00182ec3ee636a"
