require gitlab-runner.inc

SRC_URI = "git://gitlab.com/gitlab-org/gitlab-runner.git;branch=16-11-stable;protocol=https"
SRCREV = "535ced5fe5988490061ce316fc49529575e8e58b"
