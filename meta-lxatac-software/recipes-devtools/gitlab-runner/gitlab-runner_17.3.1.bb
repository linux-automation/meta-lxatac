require gitlab-runner.inc

SRC_URI = "git://${GO_IMPORT};branch=17-3-stable;protocol=https;destsuffix=${BPN}-${PV}/src/${GO_IMPORT}"
SRCREV = "66269445606da32c52be605feba6d70fc1a8fb0d"
