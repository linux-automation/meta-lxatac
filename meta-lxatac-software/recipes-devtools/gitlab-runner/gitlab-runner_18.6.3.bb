require gitlab-runner.inc

SRCBRANCH = "18-6-stable"
SRCREV = "dbac4904553947d823cf632ac928023ec2c9a987"
