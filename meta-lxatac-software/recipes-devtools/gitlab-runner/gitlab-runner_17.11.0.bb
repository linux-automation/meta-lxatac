require gitlab-runner.inc

SRC_URI = "git://${GO_IMPORT};branch=17-11-stable;protocol=https;destsuffix=${BPN}-${PV}/src/${GO_IMPORT}"
SRCREV = "0f67ff190a5f069ef1e46f2a8950e1319e71d6e4"
