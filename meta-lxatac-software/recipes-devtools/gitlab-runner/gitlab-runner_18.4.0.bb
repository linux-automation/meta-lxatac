require gitlab-runner.inc

SRCBRANCH = "18-4-stable"
SRCREV = "139a0ac033907890894642625cdfabf215c614fd"
