# duktape is an alternative javascript intrepreter that is more lightweight
# than mozjs, which is as of now the default interpreter.
PACKAGECONFIG = "duktape systemd"
