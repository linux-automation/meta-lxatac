SRCREV = "554a5c7eb35c060a973c1abcc592086f689c82d2"
PR:append = "+gitr${SRCREV}"
