PV = "1.1.120"
SRCREV = "394a01f742e640c3aff0e87d4e0529e57d977ec5"

SRC_URI:remove = "file://0001-CMakeLists-do-not-use-vendored-libcurl.patch"
